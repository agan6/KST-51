# Keil uVision project 作业.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 作业 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Include;..\User
  group User
    ./: main.c main.h STARTUP.A51
  group Driver
    ../Driver/: led.c keyboard.c ds18b20.c ds1302.c lcd1602.c time.c temp.c
  group Include
    ../Include/: led.h keyboard.h ds18b20.h ds1302.h lcd1602.h config.h temp.h
